# Keil uVision project wanlix.uvproj, settings and files
target RTOS_Wanlix (ARM-GNU)
  device: ADuC7026 Analog Devices
  cpu: IRAM(0x10000-0x11FFF) IROM(0x80000-0x8F7FF) CLOCK(32768) CPUTYPE(ARM7TDMI)
  output: wanlix +hex
  group wanlix
    ../wanlix/: wlx_core_a.asm wlx_core_c.c
  group srccode
    ../srccode/: wlx_userboot.c device.c test.c unoptimize.c
  group others
    ../others/: startup.s ADuC702X.ld
